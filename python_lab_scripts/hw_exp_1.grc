options:
  parameters:
    generate_options: qt_gui
    id: hw_exp_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: dect2_packet_decoder_0
  id: dect2_packet_decoder
  parameters:
    rx_id: '0'
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '2'
    differential: 'False'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '8'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'False'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '8'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 3586.56e6
    gain0: '50'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: 3586.56e6
    gain0: '50'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}

connections:
- [dect2_packet_decoder_0, '0', digital_psk_mod_0, '0']
- [digital_psk_demod_0, '0', dect2_packet_decoder_0, '0']
- [digital_psk_mod_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
