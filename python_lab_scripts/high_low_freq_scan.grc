options:
  parameters:
    generate_options: qt_gui
    id: freq_scan
    output_language: python
    title: freq_scan
  states: {}

blocks:
- name: cutoff_freq
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tran_width
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: tran_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: tran_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 3586.98e6
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_null_source_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
