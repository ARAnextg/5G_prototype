options:
  parameters:
    author: vrunads27
    generate_options: qt_gui
    id: ofdm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./xyz.txt
    type: byte
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '128'
    fft_len: '512'
    header_mod: '"BPSK"'
    occupied_carriers: '480'
    packet_len_key: packet_len
    payload_mod: '"BPSK"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 3586.56e6
    gain0: '50'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [digital_ofdm_rx_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
